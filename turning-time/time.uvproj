# Keil uVision project time.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: time +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: Delay.c main.c motor.c
  group Header
    ./: config.h Delay.h main.h motor.h
