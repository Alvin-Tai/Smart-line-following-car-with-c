# Keil uVision project testcar.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: testcar +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: Delay.c main.c motor.c servo.c timer_ISR.c
  group Header
    ./: config.h Delay.h main.h motor.h Servo.h timer_ISR.h
