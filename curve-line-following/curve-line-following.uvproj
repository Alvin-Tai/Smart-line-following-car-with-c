# Keil uVision project curve-line-following.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: curve-line-following +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: app.c Delay.c main.c motor.c servo.c timer_ISR.c
  group Header
    ./: app.h config.h Delay.h main.h motor.h Servo.h timer_ISR.h
